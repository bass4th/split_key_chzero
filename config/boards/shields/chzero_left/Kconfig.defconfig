## config/boards/shields/chzero_left/Kconfig.defconfig
```kconfig
if SHIELD_CHZERO_LEFT

config ZMK_KEYBOARD_NAME
    default "CHZero Left"

endif
```
